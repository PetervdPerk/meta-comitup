# Disable resolved package since it conflicts with dnsmasq

PACKAGECONFIG_remove = "resolved"
